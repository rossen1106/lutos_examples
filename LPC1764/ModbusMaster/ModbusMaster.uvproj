# Keil uVision project ModbusMaster.uvproj, settings and files
target ModbusMaster (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ModbusMaster
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Application
    ./: main.c lutos_cfg.h
  group Lutos
    ../../../lutos/main/: debug.c flag.c heap.c modbus_m.c queue.c ring.c task.c tick.c
  group Port
    ../../../lutos/port/rvmdk/LPC17xx/: crc16.c port.c setbaud.c multidrop_uart.c
