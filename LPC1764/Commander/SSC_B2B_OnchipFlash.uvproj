# Keil uVision project SSC_B2B_OnchipFlash.uvproj, settings and files
target Commander (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Commander
  c flags: Optim=1
  c define: RVMDK_ARM_CM3_LPC17xx LPC17XX
  c include: .;..\..\..\lutos\include;..\..\..\lutos\port\rvmdk\LPC17xx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Application
    ./: lutos_cfg.h main_b2b_pm.c
  group Lutos
    ../../../lutos/main/: b2b_s.c debug.c flag.c heap.c queue.c ring.c task.c tick.c commander.c
  group Port
    ../../../lutos/port/rvmdk/LPC17xx/: port.c setbaud.c multidrop_uart.c gpio.c crc16.c
    ./: flash_nvol.c
