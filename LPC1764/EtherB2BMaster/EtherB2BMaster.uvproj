# Keil uVision project EtherB2BMaster.uvproj, settings and files
target EtherB2BMaster (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ethB2bMaster +hex (library)
  c flags: Optim=3
  c define: RVMDK_ARM_CM3_LPC17xx
  c include: .;..\..\..\..\..\LUTOS\code\lutos\include;..\..\..\..\..\LUTOS\code\lutos\port\rvmdk\LPC17xx;..\..\..\..\..\LUTOS\code\lutos\port\rvmdk\LPC17xx\lpclwip;..\..\..\..\..\lwip\lwip\src\include;..\..\..\..\..\lwip\lwip\src\include\ipv4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Lutos
    ../../../../../LUTOS/code/lutos/main/: heap.c queue.c task.c tick.c
    ../../../lutos/main/: b2b_m.c b2b_m_udp.c
  group Port
    ../../../../../LUTOS/code/lutos/port/rvmdk/LPC17xx/: port.c gpio.c emac_netif.c emac_phy_dp83848.c i2c_m.c
    ../../../../../LUTOS/code/lutos/port/rvmdk/LPC17xx/lpclwip/arch/: lpc17xx_systick_arch.c lpc_debug.c
    ./: s24_eeprom.c
  group Aplication
    ./: lutos_cfg.h ethernet.c lwipopts.h main_group.c
  group lwip
    ../../../../../lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../lwip/lwip/src/netif/: etharp.c
