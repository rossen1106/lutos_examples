# Keil uVision project LowSpeedSampling.uvproj, settings and files
target LowSpeedSampling (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LowSpeedSampling
  c flags: Optim=1 oTime=1
  c define: RVMDK_ARM_CM3_LPC17xx
  c include: ..\..\..\lutos\include;.
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Application
    ./: main.c lutos_cfg.h
  group Lutos
    ../../../lutos/main/: flag.c heap.c queue.c ring.c task.c tick.c
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Lutos-port
    ../../../lutos/port/rvmdk/LPC17xx/: port.c debug_uart.c
