# Keil uVision project LowSpeedSampling.uvproj, settings and files
target LowSpeedSampling (ARM-ADS)
  device: LPC4078 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LowSpeedSampling
  c flags: Optim=3 oTime=1
  c define: CORE_M4 RVMDK_ARM_CM4_LPC40xx
  c include: .;..\..\..\lutos\include;..\..\..\lutos\port\rvmdk\LPC407x_8x
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c lutos_cfg.h
  group Lutos
    ../../../lutos/main/: flag.c heap.c queue.c ring.c task.c tick.c
  group Startup
    ./: system_LPC407x_8x_177x_8x.c startup_LPC407x_8x_177x_8x.s
  group Lutos-port
    ../../../lutos/port/rvmdk/LPC407x_8x/: port.c debug_uart.c gpio.c i2c_m.c setbaud.c uart.c
