# Keil uVision project B2BMaster.uvproj, settings and files
target B2BMaster (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: B2BMaster
  c flags: Optim=1
  c define: rvmdk PART_LM3S6965 RVMDK_ARM_CM3
  c include: ..\..\..\lutos\include;.;C:\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Application
    ./: Startup.s main.c lutos_cfg.h
    C:/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Lutos
    ../../../lutos/main/: ring.c fsm.c flag.c debug.c heap.c queue.c task.c tick.c b2b_m.c b2b_s.c
  group port
    ../../../lutos/port/rvmdk/LM3S9B92/: port.c multidrop_uart.c
